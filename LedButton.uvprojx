# Keil uVision project LedButton.uvprojx, settings and files
target LedMgmtByButton (6190000::V6.19::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LedMgmtByButton +hex
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c include: ..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup;..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\..\lib\MDR32F9Qx_StdPeriph_Driver\inc;..\..\lib\Config;..\..\..\lib\MDR32F9Qx_StdPeriph_Driver\inc;..\..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup;..\..\..\lib\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: button.c clk.c led.c main.c button.h clk.h led.h type_custom.h
  group DeviceSupport
    ../../lib/CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    ../../lib/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s
    ../../lib/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/: system_MDR32F9Qx.h system_MDR32F9Qx.c
  group StdPeriphDriver
    ../../lib/MDR32F9Qx_StdPeriph_Driver/inc/: MDR32F9Qx_port.h MDR32F9Qx_rst_clk.h
    ../../lib/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
software components: CMSIS:CORE 5.6.0
